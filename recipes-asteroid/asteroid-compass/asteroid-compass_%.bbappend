FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://0001-show-uncalibrated-readings.patch"
