PACKAGE_INSTALL:append:hoki = " hoki-rootfs-initramfs"
